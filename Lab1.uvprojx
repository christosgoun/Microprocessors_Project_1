# Keil uVision project Lab1.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c compute_hash.s compute_clearance.s lucas_sequence.s compute_checksum.s
software components: CMSIS-Compiler:CORE 1.2.0, CMSIS-Compiler:STDERR:ITM 1.1.0, CMSIS-Compiler:STDIN:ITM 1.1.0, CMSIS-Compiler:STDOUT:ITM 1.1.0, CMSIS:CORE 6.2.0, Device:Startup 2.6.3
